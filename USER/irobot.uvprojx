# Keil uVision project irobot.uvprojx, settings and files
target SysTick-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: irobot +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\wifi_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\irobot.sct
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c iclean.c cfg.c ringbuffer.c task_rx.c sensers.c navigation.c sys.c randclean.c charge.c libatcharge.c ny3p.c map.c action.c rtc_lib.c KEY.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
    ./: gyro.lib
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ./: adc.c usart.c PID.c stm32f10x_it.c SysTick.c bsp.c motor.c i2c.c spi.c spi.h TempTrans.c test_mode.c bootloader.c mpu6500.c dispprot.c ee_iic.c
  group wifi_sdk
    ./wifi_sdk/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 4.3.0
